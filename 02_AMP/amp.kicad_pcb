# Repository YeetTheAnson/ParametricSpeaker

File README.md:

# ParametricSpeaker

## Overview
This is a repository for the design of a parametric speaker, which uses ultrasonic waves to AM modulate audible sound and emit it with high directionality.  
The content is explained in the video below, so please check it out as well.  

## AM Modulation Board (01_MC1496)
This is a board that performs AM modulation using the MC1496 IC.  
The carrier wave input supports both a sine wave from a function generator (FG) and a square wave generated by a microcontroller.  
The power supply input is designed for ±12V.

### Design Modifications
- **R8, 9, 10, 11**  
  Changed to 100Ω. Due to in-house component stock availability.
- **R7**  
  Stack two 100Ω resistors to create 50Ω.  
  Due to in-house component stock availability.
- **R13**  
  Changed to 220Ω.  
  For adjusting the amplifier gain.
- **RV1**  
  The value is almost fixed, so a variable resistor is not necessary. Use two 22kΩ resistors to create a voltage divider.
- **RV2**  
  Changed to a 50kΩ variable resistor.  
  For adjusting the amplifier gain.

## Amplifier Board (02_AMP)
This board amplifies the modulated wave using an LM1875.  
The power supply voltage is rated for up to ±30V, but when driving 30 ultrasonic speakers, it continuously consumes about 7W. Careful attention must be paid to heat generation.  
It will also work fine with around ±15V, but you will need to adjust the amplifier's gain accordingly.  

### Design Modifications
- **R5**  
  This is not populated, as a variable resistor will be installed instead.
- **R6**  
  A 50kΩ variable resistor is populated here.
- **R3**  
  Changed to 220Ω.
- **C1**  
  Only the top-side footprint for C1 is populated. Changed to a 1uF, 1206 size capacitor.
- **C6**  
  Changed to a 10uF, 1206 MLCC.

## Speaker Array Board (03_SpeakerArray)
This is a speaker array board where 30 ultrasonic speakers are arranged in parallel.  
There are provisions to add a resistor and capacitor in series with each speaker (these were not used in the actual build).  
Please pay attention to the polarity of the speakers. This is to ensure all piezoelectric elements bend in the same direction when voltage is applied.

## KiCad design 02_AMP/amp.kicad_pcb

Parts:
C1: 2.2u; C_1206_3216Metric
C2, C3: 0.1u; C_0603_1608Metric
C4, C5: 100u; CP_Radial_Tantal_D6.0mm_P2.50mm
C6: 22u; CP_Radial_Tantal_D6.0mm_P2.50mm
J1: Screw_Terminal_01x03; TerminalBlock_bornier-3_P5.08mm
J2, J3: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
R1: 1M; R_0603_1608Metric
R2: 22k; R_0603_1608Metric
R3: 1k; R_0603_1608Metric
R4: 10k; R_0603_1608Metric
R5: 4.7k; R_0603_1608Metric
R6: 4.7k; PinHeader_1x02_P2.54mm_Vertical
TP1: Vin; TestPoint_THTPad_D2.5mm_Drill1.2mm
TP2: Vin_AC; TestPoint_THTPad_D2.5mm_Drill1.2mm
TP3: Vout; TestPoint_THTPad_D2.5mm_Drill1.2mm
TP4, TP5, TP6: GND; TestPoint_THTPad_D2.5mm_Drill1.2mm
U1: LM1875; TO-220-5_P3.4x3.7mm_StaggerOdd_Lead3.8mm_Vertical

Connections:
+30V: C2.1, C4.1, J1.3, U1.5 (V+)
-30V: C3.1, C5.2, J1.1, U1.3 (V-)
GND: C2.2, C3.2, C4.2, C5.1, C6.2, J1.2, J2.2, J3.1, R1.2, R2.2, TP4.1, TP6.1
unnamed: C6.1, R3.2
unnamed: R4.2, R5.1, R6.1
unnamed: R3.1, R4.1, U1.2 (-)
Vin: C1.1, J3.2, R1.1, TP1.1; also elsewhere on the board
Vin_AC: C1.2, R2.1, TP2.1, U1.1 (+); also elsewhere on the board
Vout: J2.1, R5.2, R6.2, TP3.1, U1.4

Notes on the sheet:
可変抵抗実装用

Board: 2 copper layers, 63.0 x 53.5 mm, 23 parts (1 on the bottom side), 9 nets.

Other parts of the board:
C7: 2.2u; C_1206_3216Metric

Their connections:
Vin: C7.1; also elsewhere on the board
Vin_AC: C7.2; also elsewhere on the board

## KiCad design 03_SpeakerArray/SpeakerArray.kicad_pcb

Parts:
C1: C; C_Disc_D4.7mm_W2.5mm_P5.00mm
J1: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
LS1, LS2, LS3, LS4, LS5, LS6, LS7, LS8, LS9, LS10, LS11, LS12, LS13, LS14, LS15, LS16, LS17, LS18, LS19, LS20, LS21, LS22, LS23, LS24, LS25, LS26, LS27, LS28, LS29, LS30: Speaker_Ultrasound; CUSP-T80-18-2400-TH
R1: R; R_Axial_Power_L25.0mm_W6.4mm_P27.94mm

Connections:
unnamed: C1.1, R1.2
unnamed: J1.2, R1.1
Spk+: C1.2, LS1.1, LS2.1, LS3.1, LS4.1, LS5.1, LS6.1, LS7.1, LS8.1, LS9.1, LS10.1, LS11.1, LS12.1, LS13.1, LS14.1, LS15.1, LS16.1, LS17.1, LS18.1, LS19.1, LS20.1, LS21.1, LS22.1, LS23.1, LS24.1, LS25.1, LS26.1, LS27.1, LS28.1, LS29.1, LS30.1
Spk-: J1.1, LS1.2, LS2.2, LS3.2, LS4.2, LS5.2, LS6.2, LS7.2, LS8.2, LS9.2, LS10.2, LS11.2, LS12.2, LS13.2, LS14.2, LS15.2, LS16.2, LS17.2, LS18.2, LS19.2, LS20.2, LS21.2, LS22.2, LS23.2, LS24.2, LS25.2, LS26.2, LS27.2, LS28.2, LS29.2, LS30.2

Board: 2 copper layers, 130.2 x 101.5 mm, 33 parts (0 on the bottom side), 4 nets.

## Commit log

2025-03-05 project setup
2025-03-05 新規シンボル作成
2025-03-08 LTspiceシミュレーション追加
2025-03-08 lt1210追加
2025-03-09 lt1210とLC共振
2025-03-11 共振回路
2025-03-11 アンプの出力幅目一杯使う方向性で
2025-03-13 ファイル名変更
2025-03-13 ディレクトリ移動
2025-03-13 add amp
2025-03-13 スピーカアレイ回路追加
2025-03-13 ディレクトリ整理
2025-03-13 フットプリントライブラリ以降
2025-03-13 マイク端子とアンプ
2025-03-14 SeeedXiao配置
2025-03-14 基板配置
2025-03-14 搬送波生成用SeeedXiaoをピンソケットで配置できるようにフットプリントをスルーホールに変更 #1
2025-03-14 A1から40.3kHzのPWM出力するコード #1
2025-03-14 シルクで基板名とロゴ配置
2025-03-14 TP名設定
2025-03-14 基板外形修正 #1
2025-03-14 VcとVc_ACのTP分割
2025-03-14 未配線塗りつぶし領域にvia配置 #1
2025-03-14 TP名修正
2025-03-14 スピーカのフットプリント作成 #2
2025-03-14 仮配置 #2
2025-03-17 ベタ面にvia
2025-03-17 シルク位置調整
2025-03-17 外形微調整、シルク配置
2025-03-17 搬送波分圧調整
2025-03-17 マイコン周りvia追加
2025-03-17 ターミナルにシルク追加
2025-03-17 部品仮配置
2025-03-17 基板外形仮設定 #3
2025-03-17 ベタ面とvia配置
2025-03-17 ターミナルのピンアサインシルク
2025-03-17 ベタ面にvia #3
2025-03-17 via追加 #3
2025-03-17 ベタ除去、パターン配線のみに変更 #2
2025-03-17 C1裏面に予備パッド #3
2025-03-17 TP名修正 #3
2025-03-17 基板書き出し
2025-03-26 RCフィルタで矩形波の高周波成分をカットしてみる実験
2025-03-28 AM変調基板の修正箇所をreadmeに追記
2025-03-28 アンプ基板設計修正箇所追記 #8
2025-06-02 ディレクトリ名変更
2025-06-02 ライブラリ追加
2025-06-06 readmeに動画リンク追加
2025-06-06 ですます調で統一
2025-07-12 Machine translation
